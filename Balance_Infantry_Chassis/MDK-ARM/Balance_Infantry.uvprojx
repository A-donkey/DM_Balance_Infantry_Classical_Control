# Keil uVision project Balance_Infantry.uvprojx, settings and files
target Balance_Infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Balance_Infantry +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../External_Device/BMI088/Inc;../Controller/Inc;../Task/Inc;../Math/Inc;../Motor/Inc;../Bsp/Inc;../APP/Inc;../Judge/Inc;../Parameter_Tree;../Config;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  link misc: --entry Reset_Handler
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c crc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group External_Device/BMI088
    ../External_Device/BMI088/Src/: BMI088driver.c BMI088Middleware.c
    ../External_Device/BMI088/Inc/: BMI088driver.h BMI088Middleware.h BMI088reg.h
  group Controller
    ../Controller/Src/: LQR.c PID.c LESO.c
    ../Controller/Inc/: LQR.h PID.h LESO.h leso_parameters.h
  group Task
    ../Task/Src/: Board_Can_Task.c Chassis_Task.c Check_Task.c Ins_Task.c Ref_Task.c Super_Cap_Task.c
    ../Task/Inc/: Board_Can_Task.h Chassis_Task.h Check_Task.h Ins_Task.h Ref_Task.h Super_Cap_Task.h
  group Math
    ../Math/Src/: kalman_filter.c QuaternionEKF.c user_lib.c wheel_kalman.c
    ../Math/Inc/: kalman_filter.h QuaternionEKF.h user_lib.h wheel_kalman.h
  group Motor
    ../Motor/Src/: Damiao_Motor.c Dji_Motor.c
    ../Motor/Inc/: Damiao_Motor.h Dji_Motor.h
  group Bsp
    ../Bsp/Src/: bsp_buzzer.c bsp_can.c bsp_dwt.c bsp_PWM.c bsp_rc.c
    ../Bsp/Inc/: bsp_buzzer.h bsp_can.h bsp_dwt.h bsp_PWM.h bsp_rc.h
  group App
    ../APP/Src/: Buzzer_Run.c Can_Feedback.c Power_Limit.c Remote_Control.c Self_Rescue.c Some_Functions.c Super_Cap.c VMC.c Vofa.c VT03.c
    ../APP/Inc/: Buzzer_Run.h Can_Feedback.h Power_Limit.h Remote_Control.h Self_Rescue.h Some_Functions.h Super_Cap.h VMC.h Vofa.h VT03.h
  group Judge
    ../Judge/Src/: CRCs.c fifo.c Referee.c
  group Parameter
    ../Parameter_Tree/: Parameter.h
  group Config
    ../Config/: can_config.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
